# Keil uVision project PS2_Demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PS2_Demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\DebugConfig\CORE;.\Start;.\System;.\Hardware;.\Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./DebugConfig/CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c App.c PS2GamePad.c Filter.c Filter.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: myMOTOR.c myMOTOR.h solve.c solve.h TIME.c TIME.h AHRS.c AHRS.h IMUSerial.c IMUSerial.h IMU_Multi.c IMU_Multi.h
software components: CMSIS:CORE 5.0.1
